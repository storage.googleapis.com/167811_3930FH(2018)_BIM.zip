Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-07-11T18:13:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jul 11 18:13:12 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{05C137D1-4F28-4E6A-844D-2E205E7FC5F3}\ifc * Database version: 5507 * Database creation date: Thu Jul 11 18:13:08 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jul 11 18:13:08 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jul 11 18:13:08 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 3930FH Kitchen faucet, 3930FH(2018):3930FH Kitchen faucet:361791
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; NominalDepth: 255 mm; NominalHeight: 169 mm; NominalWidth: 51 mm; Projection: 215 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 3930FH(2018); ConvergoRefNr: 0087-1909-0001-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_45; Uniclass2015Description: Sink manual water supply sets; Uniclass2015Reference: Pr_40_20_87_82; Version: 1; VersionDate: 03/07/2019
Type - Green Building Properties(Type) - Customs Code: 84818011; EAN Number: 6414150089091; EN Standard: EN 817; Noise Class: I(ISO3822); VVS Number: 705917404
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/3930FH; Catalog Drawing URL: http://static.oras.com/catdrw/3930FH; Class: Single lever; Dimension Drawing URL: http://static.oras.com/dimdrw/3930FH; FDV Document URL: http://www.oras.com/datasheet/3930FH/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/3930FH; Group: Kitchen faucets; Long Marketing: Oras Saga Style kitchen faucet with swivel spout and aerator. Spout's swing angle is factory preset at 120° (can be limited to 40°-80°). There are also in-built limitation options for water temperature and maximum flow-rate. 3S-Installation system. F= with flexible pipes; Manufacturer: Oras; Market: DNK;RUS; Model: 3930FH Kitchen faucet; Name_en: 3930FH Kitchen faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 362 x 278 x 63; Package Weight: 1.925 kg; Product Code: 3930FH; Product Datasheet: http://www.oras.com/datasheet/3930FH/en; Product Family: Oras Saga Style; Product Image URL: http://static.oras.com/image/3930FH; Product URL: http://static.oras.com/3930FH; Type Name: 3930FH Kitchen faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: 3S-Installation; Connection Size: G3/8; Flow Rate At 300kPa: 0.00565035 m3/s; Installation and Maintenance: http://static.oras.com/manual/3930FH; Installation Type: Deck mounted; Lever Handle: Single Operating Lever; Max. Hot Water Supply: 80 kg/K/s3; Mounting Holes: 1 Mounting Hole; Spare Parts: http://static.oras.com/sp/3930FH
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 3930FH(2018); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 3930FH; Name: 3930FH Kitchen faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 50x255x170 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 3930FH; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 3930FH Kitchen faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0658185 m2; Volume: 0.00220256 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 3930FH(2018): 3930FH Kitchen faucet; Family and Type: 3930FH(2018): 3930FH Kitchen faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 3930FH(2018): 3930FH Kitchen faucet; Type Id: 3930FH(2018): 3930FH Kitchen faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
